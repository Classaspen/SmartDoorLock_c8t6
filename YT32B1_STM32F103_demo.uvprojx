# Keil uVision project YT32B1_STM32F103_demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Basic\delay;.\Basic\sys;.\Hardware\LED;.\Basic\i2c;.\Hardware\SG90;.\Basic\pwm;.\Hardware\KEY;.\Hardware\LM75A;.\Hardware\BUZZER;.\Basic\usart;.\Hardware\RUN;.\Basic\usart2;.\Basic\timer;.\Basic\wdg;.\Basic\delay;.\Hardware\OLED;.\Hardware\BEEP;.\Hardware\as608;.\Hardware\as608;.\Basic\nvic;.\Hardware\oled1;.\Basic\flash;.\Hardware\KEYPAD4x4;.\Hardware\SG90;.\Hardware\BEEP;.\Basic\usart3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/timer/: timer.c
    ./Basic/usart2/: usart2.c
    ./Basic/usart/: usart.c
    ./Basic/nvic/: NVIC.c
    ./Basic/flash/: flash.c
    ./Basic/usart3/: usart3.c
  group Hardware
    ./Hardware/OLED/: OLED_I2C.c
    ./Hardware/BEEP/: BEEP.c
    ./Hardware/as608/: as608.c
    ./Hardware/LED/: led.c
    ./Hardware/SG90/: SG90.c
software components: CMSIS:CORE 5.4.0
